# Keil uVision project ucosii_led.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F070RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ucosii_led +hex
  c flags: Optim=1
  c include: ..\user;..\uCOS-II\Ports;..\uCOS-II\Source;..\stm32f0;..\lib\inc;..\lib\src;..\drive;..\..\ucosii_led;..\uCOS-II\Ports;F:\Keil_v5\ARM\Pack\Keil\STM32F0xx_DFP\1.5.0\Device\Include;..\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_stm32f0xx.s
    ../stm32f0/: stm32f0xx_it.c
    F:/Keil_v5/ARM/Pack/Keil/STM32F0xx_DFP/1.5.0/Device/Source/: system_stm32f0xx.c
  group user
    ./: main.c
  group drive
    ../drive/: led.c
  group ucosii\port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group ucosii\source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
